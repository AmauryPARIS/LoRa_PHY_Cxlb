<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lora_TX</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX_gain</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cr</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_period</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>has_crc</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>impl_head</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_frame</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>bw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sf</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("Hello world")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>lora_sdr_add_crc</key>
<param><key>id</key><value>lora_sdr_add_crc_0</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
</block>
<block>
<key>lora_sdr_gray_decode</key>
<param><key>id</key><value>lora_sdr_gray_decode_0</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_hamming_enc</key>
<param><key>id</key><value>lora_sdr_hamming_enc_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_header</key>
<param><key>id</key><value>lora_sdr_header_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
</block>
<block>
<key>lora_sdr_interleaver</key>
<param><key>id</key><value>lora_sdr_interleaver_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_modulate</key>
<param><key>id</key><value>lora_sdr_modulate_0</value></param>
<param><key>bw</key><value>bw</value></param>
<param><key>minoutbuf</key><value>10000000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_whitening</key>
<param><key>id</key><value>lora_sdr_whitening_0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>center_freq0</key><value>915e6</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>TX_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>strobe</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lora_sdr_add_crc_0</sink_block_id><source_key>strobe</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lora_sdr_header_0</sink_block_id><source_key>strobe</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lora_sdr_interleaver_0</sink_block_id><source_key>strobe</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lora_sdr_modulate_0</sink_block_id><source_key>strobe</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lora_sdr_whitening_0</sink_block_id><source_key>strobe</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>lora_sdr_add_crc_0</source_block_id><sink_block_id>lora_sdr_hamming_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_gray_decode_0</source_block_id><sink_block_id>lora_sdr_modulate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_hamming_enc_0</source_block_id><sink_block_id>lora_sdr_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_header_0</source_block_id><sink_block_id>lora_sdr_add_crc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_interleaver_0</source_block_id><sink_block_id>lora_sdr_gray_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_modulate_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_whitening_0</source_block_id><sink_block_id>lora_sdr_header_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
