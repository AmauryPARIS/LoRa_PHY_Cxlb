<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_lora_rx</value></param>
<param><key>category</key><value>[LoRa - hier]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>LoRa - RX Chain</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>block_id</key><value>lora_sdr_perf_collector_0</value></param>
<param><key>function_name</key><value>send_intel</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bw</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cr</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>has_crc</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hist_avg</value></param>
<param><key>label</key><value>Hisorical length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>impl_head</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>lora_sdr_crc_verif</key>
<param><key>id</key><value>lora_sdr_crc_verif_0</value></param>
</block>
<block>
<key>lora_sdr_decim_factor_modifier</key>
<param><key>id</key><value>lora_sdr_decim_factor_modifier_0</value></param>
<param><key>Sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_deinterleaver</key>
<param><key>id</key><value>lora_sdr_deinterleaver_0</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_dewhitening</key>
<param><key>id</key><value>lora_sdr_dewhitening_0</value></param>
</block>
<block>
<key>lora_sdr_fft_demod</key>
<param><key>id</key><value>lora_sdr_fft_demod_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_frame_sync</key>
<param><key>id</key><value>lora_sdr_frame_sync_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_gray_enc</key>
<param><key>id</key><value>lora_sdr_gray_enc_0</value></param>
</block>
<block>
<key>lora_sdr_hamming_dec</key>
<param><key>id</key><value>lora_sdr_hamming_dec_0</value></param>
</block>
<block>
<key>lora_sdr_header_decoder</key>
<param><key>id</key><value>lora_sdr_header_decoder_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
<param><key>pay_len</key><value>pay_len</value></param>
</block>
<block>
<key>lora_sdr_perf_collector</key>
<param><key>id</key><value>lora_sdr_perf_collector_0</value></param>
<param><key>sf</key><value>sf</value></param>
<param><key>udp_rx_port</key><value>udp_rx_port</value></param>
</block>
<block>
<key>lora_sdr_pwr_est</key>
<param><key>id</key><value>lora_sdr_pwr_est_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>history_avg</key><value>hist_avg</value></param>
<param><key>noise_elem</key><value>noise_elem</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_elem</value></param>
<param><key>label</key><value>Noise history for SNR</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_rx</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>MSG</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_rx</value></param>
<param><key>label</key><value>stream</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pay_len</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sf</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udp_rx_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>6790</value></param>
</block>
<connection><source_block_id>lora_sdr_crc_verif_0</source_block_id><sink_block_id>lora_sdr_perf_collector_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>lora_sdr_crc_verif_0</source_block_id><sink_block_id>pad_sink_rx</sink_block_id><source_key>msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_sdr_crc_verif_0</source_block_id><sink_block_id>lora_sdr_perf_collector_0</sink_block_id><source_key>valid</source_key><sink_key>valid_msg</sink_key></connection>
<connection><source_block_id>lora_sdr_decim_factor_modifier_0</source_block_id><sink_block_id>lora_sdr_pwr_est_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_deinterleaver_0</source_block_id><sink_block_id>lora_sdr_hamming_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_dewhitening_0</source_block_id><sink_block_id>lora_sdr_crc_verif_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_fft_demod_0</source_block_id><sink_block_id>lora_sdr_gray_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_deinterleaver_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_fft_demod_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_hamming_dec_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_header_decoder_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_fft_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_decim_factor_modifier_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_gray_enc_0</source_block_id><sink_block_id>lora_sdr_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_hamming_dec_0</source_block_id><sink_block_id>lora_sdr_perf_collector_0</sink_block_id><source_key>corrected</source_key><sink_key>err_corrected</sink_key></connection>
<connection><source_block_id>lora_sdr_hamming_dec_0</source_block_id><sink_block_id>lora_sdr_perf_collector_0</sink_block_id><source_key>detected</source_key><sink_key>err_detected</sink_key></connection>
<connection><source_block_id>lora_sdr_hamming_dec_0</source_block_id><sink_block_id>lora_sdr_header_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_deinterleaver_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_fft_demod_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_hamming_dec_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_perf_collector_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_crc_verif_0</sink_block_id><source_key>CRC</source_key><sink_key>CRC</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>CRC</source_key><sink_key>CRC</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>CRC</source_key><sink_key>crc</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>err</source_key><sink_key>err</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_crc_verif_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_perf_collector_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>lora_sdr_pwr_est_0</source_block_id><sink_block_id>lora_sdr_perf_collector_0</sink_block_id><source_key>MSG_Energy</source_key><sink_key>MSG_Energy</sink_key></connection>
<connection><source_block_id>lora_sdr_pwr_est_0</source_block_id><sink_block_id>lora_sdr_perf_collector_0</sink_block_id><source_key>Noise_Energy</source_key><sink_key>Noise_Energy</sink_key></connection>
<connection><source_block_id>lora_sdr_pwr_est_0</source_block_id><sink_block_id>lora_sdr_perf_collector_0</sink_block_id><source_key>SNR</source_key><sink_key>SNR</sink_key></connection>
<connection><source_block_id>lora_sdr_pwr_est_0</source_block_id><sink_block_id>lora_sdr_perf_collector_0</sink_block_id><source_key>msg_avg</source_key><sink_key>msg_avg</sink_key></connection>
<connection><source_block_id>lora_sdr_pwr_est_0</source_block_id><sink_block_id>lora_sdr_perf_collector_0</sink_block_id><source_key>snr_avg</source_key><sink_key>snr_avg</sink_key></connection>
<connection><source_block_id>pad_source_rx</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
