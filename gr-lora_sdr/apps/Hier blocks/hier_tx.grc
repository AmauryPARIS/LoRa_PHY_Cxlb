<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_lora_tx</value></param>
<param><key>category</key><value>[LoRa - hier]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>LoRa - TX Chain</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>comment</key><value>Test</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>mult_const</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bw</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cr</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>has_crc</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>impl_head</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>lora_sdr_add_crc</key>
<param><key>id</key><value>lora_sdr_add_crc_0</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
</block>
<block>
<key>lora_sdr_gray_decode</key>
<param><key>id</key><value>lora_sdr_gray_decode_0</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_hamming_enc</key>
<param><key>id</key><value>lora_sdr_hamming_enc_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_header</key>
<param><key>id</key><value>lora_sdr_header_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
</block>
<block>
<key>lora_sdr_interleaver</key>
<param><key>id</key><value>lora_sdr_interleaver_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_modulate</key>
<param><key>id</key><value>lora_sdr_modulate_0</value></param>
<param><key>bw</key><value>bw</value></param>
<param><key>minoutbuf</key><value>10000000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_tags_param_dyn</key>
<param><key>id</key><value>lora_sdr_tags_param_dyn_0</value></param>
</block>
<block>
<key>lora_sdr_whitening</key>
<param><key>id</key><value>lora_sdr_whitening_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mult_const</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_tx_cmd</value></param>
<param><key>label</key><value>TX_cmd</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_tx_msg</value></param>
<param><key>label</key><value>MSG</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sf</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_add_crc_0</source_block_id><sink_block_id>lora_sdr_hamming_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_gray_decode_0</source_block_id><sink_block_id>lora_sdr_modulate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_hamming_enc_0</source_block_id><sink_block_id>lora_sdr_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_header_0</source_block_id><sink_block_id>lora_sdr_add_crc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_interleaver_0</source_block_id><sink_block_id>lora_sdr_gray_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_modulate_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_tags_param_dyn_0</source_block_id><sink_block_id>lora_sdr_header_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_whitening_0</source_block_id><sink_block_id>lora_sdr_tags_param_dyn_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_tx_cmd</source_block_id><sink_block_id>lora_sdr_tags_param_dyn_0</sink_block_id><source_key>out</source_key><sink_key>TX_cmd</sink_key></connection>
<connection><source_block_id>pad_source_tx_msg</source_block_id><sink_block_id>lora_sdr_add_crc_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pad_source_tx_msg</source_block_id><sink_block_id>lora_sdr_header_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pad_source_tx_msg</source_block_id><sink_block_id>lora_sdr_interleaver_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pad_source_tx_msg</source_block_id><sink_block_id>lora_sdr_modulate_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pad_source_tx_msg</source_block_id><sink_block_id>lora_sdr_whitening_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
</flow_graph>
