<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lora_dyn_node</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>int(usrp_rx_samp_rate/bw)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX_gain</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cr</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>has_crc</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>impl_head</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mult_const</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pay_len</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>bw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rx_samp_rate</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>block_id</key><value>lora_sdr_general_supervisor_0</value></param>
<param><key>function_args</key><value>self</value></param>
<param><key>function_name</key><value>set_top_block</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>N</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>udp_tx_port</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>hier_lora_rx</key>
<param><key>id</key><value>hier_lora_rx_0</value></param>
<param><key>hist_avg</key><value>hist_avg</value></param>
<param><key>noise_elem</key><value>noise_elem</value></param>
<param><key>bw</key><value>bw</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
<param><key>pay_len</key><value>pay_len</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
<param><key>udp_rx_port</key><value>udp_rx_port</value></param>
</block>
<block>
<key>hier_lora_tx</key>
<param><key>id</key><value>hier_lora_tx_0</value></param>
<param><key>bw</key><value>bw</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
<param><key>mult_const</key><value>mult_const</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hist_avg</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>taps</key><value>-0.128616616593872,	-0.212206590789194,	-0.180063263231421,	3.89817183251938e-17	,0.300105438719035	,0.636619772367581	,0.900316316157106,	1	,0.900316316157106,	0.636619772367581,	0.300105438719035,	3.89817183251938e-17,	-0.180063263231421,	-0.212206590789194,	-0.128616616593872</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>lora_sdr_general_supervisor</key>
<param><key>id</key><value>lora_sdr_general_supervisor_0</value></param>
</block>
<block>
<key>lora_sdr_rx_tag_param_dyn</key>
<param><key>id</key><value>lora_sdr_rx_tag_param_dyn_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_elem</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sf</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udp_rx_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>6790</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udp_tx_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>6788</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>center_freq0</key><value>tx_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>TX_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>center_freq0</key><value>rx_freq</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>usrp_rx_samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>GS_msg</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>GS_sink_cmd</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>GS_source_cmd</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>GS_tx_cmd</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_0</value></param>
<param><key>stream_id</key><value>GS_rx_cmd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>GS_msg</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>GS_tx_cmd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>GS_rx_cmd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>GS_sink_cmd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>GS_source_cmd</value></param>
</block>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>hier_lora_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>lora_sdr_general_supervisor_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_lora_tx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_general_supervisor_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>GS_msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_sdr_general_supervisor_0</source_block_id><sink_block_id>virtual_sink_3_0</sink_block_id><source_key>GS_rx_cmd</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_sdr_general_supervisor_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>GS_sink_cmd</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_sdr_general_supervisor_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>GS_source_cmd</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_sdr_general_supervisor_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>GS_tx_cmd</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_sdr_rx_tag_param_dyn_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>lora_sdr_rx_tag_param_dyn_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>hier_lora_tx_0</sink_block_id><source_key>out</source_key><sink_key>MSG</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>hier_lora_tx_0</sink_block_id><source_key>out</source_key><sink_key>TX_cmd</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>lora_sdr_rx_tag_param_dyn_0</sink_block_id><source_key>out</source_key><sink_key>RX_cmd</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
</flow_graph>
